options:
  parameters:
    author: jkita
    generate_options: qt_gui
    id: lesson2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff
  id: variable_qtgui_range
  parameters:
    min_len: '10'
    start: '5'
    step: '100'
    stop: 100e3
    value: '5'
  states: {}
- name: cutoff_high
  id: variable_qtgui_range
  parameters:
    min_len: '10'
    start: cutoff_low+10
    step: '100'
    stop: cutoff_low+500e3
    value: cutoff_low+10
  states: {state: disabled}
- name: cutoff_low
  id: variable_qtgui_range
  parameters:
    min_len: '10'
    start: '0'
    step: '100'
    stop: 500e3
    value: '0'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: cutoff_high
    low_cutoff_freq: cutoff_low
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 50e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Projects\SDR\gnu-radio\light_rf_off_data
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Projects\SDR\gnu-radio\light_rf_off_data
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Projects\SDR\gnu-radio\light_rf_on_data
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: C:\Projects\SDR\gnu-radio\light_rf_data
    repeat: 'True'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    clock_source0: external_1pps
    freq0: freq
    gain0: '20'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Source"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    grid: 'True'
    name: '"Output"'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [band_pass_filter_0, '0', osmosdr_sink_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_1_0_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_file_source_0_1, '0', band_pass_filter_0, '0']
- [blocks_file_source_0_1, '0', low_pass_filter_0, '0']
- [blocks_file_source_0_1, '0', qtgui_freq_sink_x_1_0, '0']
- [low_pass_filter_0, '0', osmosdr_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_0_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
