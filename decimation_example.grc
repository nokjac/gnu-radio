options:
  parameters:
    author: jkita
    description: decimation decreases the sample rate and available bandwidth
    generate_options: qt_gui
    id: decimation_example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: 10e6
    value: '0'
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/(decimation_rate*2)
    gain: '1.0'
    samp_rate: samp_rate
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate_decimated
  id: variable
  parameters:
    value: samp_rate/decimation_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_decimated
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation_rate
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_decimated
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
