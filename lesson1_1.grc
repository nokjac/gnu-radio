options:
  parameters:
    author: jacek
    generate_options: qt_gui
    id: lesson1_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0
    min_len: '100'
    start: 5e6
    step: '500'
    stop: 40e6
    value: 10e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 98e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 100.8e6
  states: {state: disabled}
- name: channel_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    min_len: '100'
    start: 88e6
    step: 10e3
    stop: 108e6
    value: 99.2e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1
    min_len: '10'
    start: 1e3
    step: 1e3
    stop: 200e3
    value: 50e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0
    min_len: '10'
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: lpf_decim
  id: variable
  parameters:
    value: int(samp_rate/channel_width)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: 2000e3
    step: '500'
    stop: 3000e3
    value: 2048e3
  states: {state: disabled}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1
    min_len: '10'
    start: '0'
    step: '0.5'
    stop: '10'
    value: '0.5'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-70'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: lpf_decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: bandwidth
    freq0: channel_freq
    gain0: '1'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: bandwidth
    ctrlpanel: 'True'
    fc: channel_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0, 0,
    name: '"Plain singnal around the center frequency"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate/lpf_decim
    ctrlpanel: 'True'
    fc: channel_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,1
    name: '"low pass"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bandwidth
    fc: channel_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2, 0
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bandwidth
    center_freq0: channel_freq
    gain0: gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
